CONNECTIVITY_FIRMWARES_append_edison = " \
    linux-firmware-bcm43340 \
    "

IMAGE_ROOTFS_MAXSIZE = "16384"

PACKAGE_INSTALL += "kernel-module-mmc-block kernel-module-mmc-core kernel-module-sdhci kernel-module-sdhci-acpi kernel-module-sdhci-pci"

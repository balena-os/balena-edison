# FIXME
# WARNING: The license listed Intel-OBL-Binary-Firmware-License was not in the licenses collected for recipe mcu-fw-bin
NO_GENERIC_LICENSE[Intel-OBL-Binary-Firmware-License] = "LICENSE"

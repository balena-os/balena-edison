# Use the branch for the current stable kernel version (3.10.17)
SRC_URI = "git://github.com/01org/edison-bcm43340.git;branch=master;protocol=git;rev=9d609e1ffadbf8895a701e6283392bb54bd962f9"
